# Keil uVision project Motherboard.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F072C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Motherboard
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F072, USE_STDPERIPH_DRIVER
  c include: .\Source;.\Source\stdLib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Threads
    ./Source/Threads/: th_Main.c th_ModbusMaster.c
  group Standard_Lib
    ./Source/stdLib/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group uModbusMaster
    ./Source/modules/uModbusMaster/Port/: pmContext.c pmEvent.c pmSerial.c pmTimer.c
    ./Source/modules/uModbusMaster/Core/: mbm.c mbmCRC16.c mbmCRC16.h mbmUtils.c mbmUtils.h mbmFuncInput.c mbmFuncCoils.c mbmFuncHolding.c mbmFuncDisc.c mbmPort.h mbmType.h
    ./Source/modules/uModbusMaster/: mbm.h mbmConfig.h
software components: CMSIS:CORE 5.0.1, CMSIS:RTOS:Keil RTX 4.81.0, Device:Startup 1.5.0
